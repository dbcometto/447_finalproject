options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: fskMod
    output_language: python
    title: FSK Modulator
  states: {}

blocks:
- name: f_mark
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: f_space
  id: variable
  parameters:
    value: '1800'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: t_bit
  id: variable
  parameters:
    value: '0.016'
  states: {}
- name: xlating_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(np.pi*(f_mark-f_space))
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-70'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\C25Dante.Cometto\447_finalproject\samples4.dat
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("example_tag")
    file: C:\Users\C25Dante.Cometto\447_finalproject\codeword.dat
    repeat: 'False'
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\C25Dante.Cometto\447_finalproject\samples2.dat
    repeat: 'False'
    type: float
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 100*int(t_bit*samp_rate)
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (f_space+f_mark)/2
    decim: '1'
    samp_rate: samp_rate
    taps: xlating_taps
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '32768'
    name: '"Data in Frequency"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '32768'
    name: '"Shifted Signal"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Signal after Demodulation"'
    size: samp_rate
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: samp_rate
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    color1: green
    ctrlpanel: 'True'
    size: samp_rate
    srate: samp_rate
    type: float
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"Signal after Quadrature Demodulation"'
    size: samp_rate
    srate: samp_rate
    type: float
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Data in Time"'
    size: samp_rate
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:4444
    timeout: '100'
    type: float
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:4444
    timeout: '100'
    type: float
  states: {state: disabled}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://localhost:4444
    timeout: '1000'
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_2, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', blocks_head_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0_0_0, '0']
- [blocks_file_source_0_0, '0', zeromq_pub_sink_0, '0']
- [blocks_head_0, '0', blocks_throttle2_0_0, '0']
- [blocks_head_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_throttle2_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_throttle2_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_1, '0', blocks_file_sink_0, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_1, '0', zeromq_pub_sink_0_0, '0']
- [blocks_uchar_to_float_1, '0', zeromq_push_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
